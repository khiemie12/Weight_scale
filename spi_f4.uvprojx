# Keil uVision project spi_f4.uvprojx, settings and files
target Target 1 (5040049::V5.04 update 1 (build 49)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi_f4
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F40_41xxx, HSE_VALUE=8000000
  c include: ..\Tai lieu\Demos\ES_Exam2_UART;..\Tai lieu\Demos\ES_Exam2_UART\STM32F4xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ../Tai lieu/Demos/ES_Exam2_UART/: system_stm32f4xx.c system_timetick.c startup_stm32f40_41xxx.s
    ./: main.c
  group stm32f4
    ../Tai lieu/Demos/ES_Exam2_UART/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_dma.c stm32f4xx_tim.c
software components: CMSIS:CORE 5.6.0
